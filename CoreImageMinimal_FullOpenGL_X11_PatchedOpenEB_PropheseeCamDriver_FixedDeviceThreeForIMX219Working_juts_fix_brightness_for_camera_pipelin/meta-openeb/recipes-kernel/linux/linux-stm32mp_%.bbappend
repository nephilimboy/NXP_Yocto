FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-csi-i2c2-userspace-dts.patch"
